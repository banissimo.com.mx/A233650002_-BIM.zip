Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: newcast_black_1700x850_cast_iron_bath.ifc.ifc
Time: 2021-10-29T20:46:34
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Sanitary Terminal
